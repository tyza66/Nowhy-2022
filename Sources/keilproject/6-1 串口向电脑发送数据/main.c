#include <REGX52.H>
#include "Delay.h"

void UartInit(void)		//4800bps@12.000MHz
{
	PCON |= 0x80;		//????????SMOD
	SCON = 0x50;		//8???,?????
	TMOD &= 0x0F;		//?????1???
	TMOD |= 0x20;		//?????1?8???????
	TL1 = 0xF3;		//??????
	TH1 = 0xF3;		//????????
	ET1 = 0;		//?????1??
	TR1 = 1;		//?????1
	EA = 1;
	ES = 1;
}
void Send(unsigned char Byte){
	SBUF = Byte;
	while(TI==0);
	TI=0;
}
void UART_Routine() interrupt 4
{
	if(RI==1){
		P2=~SBUF;
		Send(SBUF);
		RI=0;
	}
}
main(){
	UartInit();
	while(1){
		
	}
}